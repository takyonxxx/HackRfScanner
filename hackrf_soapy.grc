options:
  parameters:
    generate_options: qt_gui
    id: hackrf_soapysdr
    output_language: python
    run: 'False'
    title: HackRf
  states: {}

blocks:
- name: audio_gain
  id: variable_qtgui_range
  parameters:
    label: Volume
    start: '0'
    step: '0.05'
    stop: '1'
    value: '0.75'
  states: {}
- name: center_freq
  id: variable_qtgui_range
  parameters:
    label: Frequency
    start: 80e6
    step: '0.1'
    stop: 108e6
    value: 100e6
  states: {}
- name: channel_width
  id: variable
  parameters:
    value: 300e3
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '12'
    quad_rate: 600e3
  states: {}
- name: audio_sink
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_gain
    type: float
  states: {}
- name: freq_sink
  id: qtgui_freq_sink_x
  parameters:
    alias: Spectrum
    average: '0.05'
    bw: sample_rate
    ctrlpanel: 'True'
    fc: center_freq
    fftsize: '1024'
    showports: 'True'
    type: complex
  states: {}
- name: hackrf_source
  id: soapy_hackrf_source
  parameters:
    center_freq: center_freq
    dev_args: hackrf=0
    gain: '40'
    samp_rate: sample_rate
    type: fc32
    vga: '40'
  states: {}
- name: low_pass_filter
  id: low_pass_filter
  parameters:
    cutoff_freq: 150e3
    decim: int(sample_rate/channel_width)
    gain: '1'
    samp_rate: sample_rate
    type: fir_filter_ccf
    width: 10e3
    win: window.WIN_HAMMING
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '6'
    interp: '12'
    type: ccc
  states: {}

connections:
- [analog_wfm_rcv_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink, '0']
- [hackrf_source, '0', freq_sink, '0']
- [hackrf_source, '0', low_pass_filter, '0']
- [low_pass_filter, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', analog_wfm_rcv_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
