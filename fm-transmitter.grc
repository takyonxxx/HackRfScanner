options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: fm_transmtter
    output_language: python
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 90.8E6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2000E3
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: int(48E3)
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: int(480E3)
    tau: '75e-6'
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /Users/turkaybiliyor/Desktop/HackRfScanner/440Hz_44100Hz_16bit_05sec.wav
    repeat: 'True'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '12'
    interp: '50'
    taps: ''
    type: ccc
  states: {}
- name: soapy_hackrf_sink_0
  id: soapy_hackrf_sink
  parameters:
    amp: 'True'
    center_freq: 100e06
    dev_args: hackraf=0
    samp_rate: 20e06
    type: fc32
  states: {}

connections:
- [analog_wfm_tx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_wavfile_source_0, '0', analog_wfm_tx_0, '0']
- [rational_resampler_xxx_0, '0', soapy_hackrf_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
