options:
  parameters:
    generate_options: qt_gui
    id: fm_transmitter
    output_language: python
  states: {}

blocks:
- name: audio_samp_rate
  id: variable
  parameters:
    value: int(44.1e3)
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: int(144e6)
  states: {}
- name: mic_gain
  id: variable_qtgui_range
  parameters:
    label: mic_gain
    start: '1'
    step: '0.1'
    stop: '5'
    value: '4'
  states: {}
- name: tx_samp_rate
  id: variable
  parameters:
    value: int(2e6)
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: audio_samp_rate
    fh: '-1.0'
    max_dev: 5e3
    quad_rate: audio_samp_rate
    tau: '75e-6'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: audio_samp_rate
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: mic_gain
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '50'
    taps: ''
    type: ccc
  states: {}
- name: soapy_hackrf_sink_0
  id: soapy_hackrf_sink
  parameters:
    amp: 'True'
    center_freq: center_freq
    dev_args: hackrf=0
    samp_rate: tx_samp_rate
    type: fc32
    vga: '29'
  states: {}

connections:
- [analog_wfm_tx_0, '0', rational_resampler_xxx_0, '0']
- [audio_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', analog_wfm_tx_0, '0']
- [rational_resampler_xxx_0, '0', soapy_hackrf_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
